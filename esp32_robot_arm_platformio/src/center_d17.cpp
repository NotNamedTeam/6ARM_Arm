#include <Arduino.h>
#include <ESP32Servo.h>

// Temporary assembly aid. Only GPIO17. One bounded test per TEST command.
constexpr uint8_t CENTER_PIN = 17;
constexpr int CENTER_US = 1500;
constexpr int PULSE_MIN_US = MIN_PULSE_WIDTH;
constexpr int PULSE_MAX_US = MAX_PULSE_WIDTH;
Servo centerServo;
int pulseUs = CENTER_US;
int commandedAngle = 90;
uint8_t testStage = 0;
unsigned long nextStageAt = 0;
unsigned long pulseCenterAt = 0;

void setPulse(int pulse) {
  pulseUs = pulse;
  commandedAngle = map(pulse, PULSE_MIN_US, PULSE_MAX_US, 0, 180);
  centerServo.writeMicroseconds(pulseUs);
}

void setAngle(int angle) {
  commandedAngle = angle;
  pulseCenterAt = 0;
  pulseUs = map(angle, 0, 180, PULSE_MIN_US, PULSE_MAX_US);
  centerServo.write(angle);  // The degree-based library call requested by the user.
}

void printAngleStatus() {
  Serial.printf("SERVO GPIO %u ANGLE %d HOLD %s\n", CENTER_PIN,
                commandedAngle, centerServo.attached() ? "ON" : "ERROR");
}

void printCenterStatus() {
  Serial.printf("CENTER GPIO %u PULSE_US %d HOLD %s\n", CENTER_PIN,
                pulseUs, centerServo.attached() ? "ON" : "ERROR");
}

void setup() {
  Serial.begin(115200);
  Serial.setTimeout(100);
  centerServo.setPeriodHertz(50);
  centerServo.attach(CENTER_PIN, PULSE_MIN_US, PULSE_MAX_US);
  if (centerServo.attached()) setAngle(90);
  printCenterStatus();
}

void loop() {
  if (Serial.available()) {
    String line = Serial.readStringUntil('\n');
    line.trim();
    if (line == "STATUS") printCenterStatus();
    else if (line == "LIMITS")
      Serial.printf("LIMITS GPIO 17 MIN_US %d MAX_US %d CENTER_US %d\n",
                    PULSE_MIN_US, PULSE_MAX_US, CENTER_US);
    else if (line == "STATUSDEG") printAngleStatus();
    else if (line.startsWith("PULSE ")) {
      int pulse = -1;
      if (sscanf(line.c_str(), "PULSE %d", &pulse) == 1 &&
          pulse >= PULSE_MIN_US && pulse <= PULSE_MAX_US && centerServo.attached()) {
        testStage = 0;
        setPulse(pulse);
        // Do not leave an uncalibrated endpoint held if the host disconnects.
        pulseCenterAt = pulse == CENTER_US ? 0 : millis() + 2000;
        printCenterStatus();
      } else Serial.printf("ERR PULSE: expected %d..%d us\n", PULSE_MIN_US, PULSE_MAX_US);
    }
    else if (line.startsWith("DEG ")) {
      int angle = -1;
      if (sscanf(line.c_str(), "DEG %d", &angle) == 1 &&
          angle >= 0 && angle <= 180 && centerServo.attached()) {
        testStage = 0;
        setAngle(angle);
        printAngleStatus();
      } else Serial.println("ERR DEG: expected 0..180");
    }
    else if (line == "TEST" && centerServo.attached() && testStage == 0) {
      pulseCenterAt = 0;
      setPulse(1000);
      testStage = 1;
      nextStageAt = millis() + 1500;
      Serial.println("TEST GPIO 17 STEP 1 PULSE_US 1000");
    } else if (line == "CENTER") {
      pulseCenterAt = 0;
      testStage = 0;
      setPulse(CENTER_US);
      printCenterStatus();
    } else if (line == "STOP") {
      pulseCenterAt = 0;
      testStage = 0;
      Serial.println("TEST STOPPED; holding current pulse");
      printCenterStatus();
    }
  }
  if (pulseCenterAt && static_cast<long>(millis() - pulseCenterAt) >= 0) {
    pulseCenterAt = 0;
    setPulse(CENTER_US);
    Serial.println("AUTO CENTER GPIO 17 PULSE_US 1500 HOLD ON");
  }
  if (testStage && static_cast<long>(millis() - nextStageAt) >= 0) {
    if (testStage == 1) {
      setPulse(2000);
      testStage = 2;
      nextStageAt = millis() + 1500;
      Serial.println("TEST GPIO 17 STEP 2 PULSE_US 2000");
    } else {
      setPulse(CENTER_US);
      testStage = 0;
      Serial.println("TEST GPIO 17 DONE PULSE_US 1500 HOLD ON");
    }
  }
  // PWM is generated by ESP32 hardware and stays enabled between queries.
  delay(2);
}
